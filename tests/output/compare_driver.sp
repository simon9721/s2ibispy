* =============================================================================
* IBIS vs SPICE Correlation Deck — driver
* Auto-generated by s2ibispy — 2025-11-25 17:36:59
* Vcc = 3.300V | Ccomp = 1.2e-12F
* Fall time (20-80%) = 0.260ns
* Rise time (20-80%) = 1.073ns

* =============================================================================

.OPTION PROBE ACCURATE RMAX=0.5
.OPTION POST_VERSION=9601
.OPTION POST=2
.TEMP 50

* === Power Supplies ===

Vsupply vdd 0 DC 3.3

Vgnd vss 0 DC 0

* === Include Transistor-Level Netlist (auto-wrapped subcircuit) ===
.INCLUDE "C:\Users\sh3qm\PycharmProjects\s2ibispy_new\tests\output\driver_wrapper.sp"

* === Input Stimulus ===
Vin_spice in_spice 0 PULSE(3.3 0 0.1n 1.0p 1.0p 25.0n 50.0n)
Vin_ibis  in_ibis  0 PULSE(3.3 0 0.1n 1.0p 1.0p 25.0n 50.0n)

* === Independent OE Control (private nodes) ===

* Independent OE control
VENA1 oe1 0 DC 3.3
VENA2 oe2 0 DC 3.3   $ Quiet line — change to DC 0 for true high-Z
VENA3 oe3 0 DC 3.3

* =============================================================================
* SPICE Side — 3 Identical Drivers (subcircuit only)
* =============================================================================
* — Using subcircuit: DRIVER_WRAPPER
* Pin order: in oe out in_sense vdd vss

X1SPICE in_spice oe1 out1SPICE sense1 vdd vss DRIVER_WRAPPER
X2SPICE vss oe2 out2SPICE sense2 vdd vss DRIVER_WRAPPER
X3SPICE in_spice oe3 out3SPICE sense3 vdd vss DRIVER_WRAPPER

* =============================================================================
* IBIS Side — 3 Identical Drivers (8-node, fully compatible)
* =============================================================================

B1IBIS vcc1io gnd1io out1IBIS in_ibis vdd rcv1 vcc1_clamp gnd1_clamp
+ file='C:\Users\sh3qm\PycharmProjects\s2ibispy_new\tests\output\test.ibs'
+ model='driver'
* + buffer=3
+ ramp_rwf=2
+ ramp_fwf=2
+ power=on
R1 rcv1 0 1k

Ccomp1 out1IBIS 0 1.2e-12

B2IBIS vcc2io gnd2io out2IBIS vss vdd rcv2 vcc2_clamp gnd2_clamp
+ file='C:\Users\sh3qm\PycharmProjects\s2ibispy_new\tests\output\test.ibs'
+ model='driver'
* + buffer=3
+ ramp_rwf=2
+ ramp_fwf=2
+ power=on
R2 rcv2 0 1k

Ccomp2 out2IBIS 0 1.2e-12

B3IBIS vcc3io gnd3io out3IBIS in_ibis vdd rcv3 vcc3_clamp gnd3_clamp
+ file='C:\Users\sh3qm\PycharmProjects\s2ibispy_new\tests\output\test.ibs'
+ model='driver'
* + buffer=3
+ ramp_rwf=2
+ ramp_fwf=2
+ power=on
R3 rcv3 0 1k

Ccomp3 out3IBIS 0 1.2e-12

* =============================================================================
* Transmission Lines — 50Ω lossless
* =============================================================================
W_SPICE N=3 out1SPICE out2SPICE out3SPICE 0
+ end1SPICE end2SPICE end3SPICE 0
+ RLGCfile="C:\Users\sh3qm\PycharmProjects\s2ibispy_new\Z50_406.lc3" l=1.2 $ 50 Ohms

W_IBIS N=3 out1IBIS out2IBIS out3IBIS 0
+ end1IBIS end2IBIS end3IBIS 0
+ RLGCfile="C:\Users\sh3qm\PycharmProjects\s2ibispy_new\Z50_406.lc3" l=1.2 $ 50 Ohms

* =============================================================================
* Probe All Critical Nodes
* =============================================================================
.PROBE TRAN
+ V(in_spice) V(in_ibis)
+ V(out1SPICE) V(out1IBIS)
+ V(out2SPICE) V(out2IBIS)
+ V(out3SPICE) V(out3IBIS)
+ V(end1SPICE) V(end1IBIS)
+ V(end2SPICE) V(end2IBIS)
+ V(end3SPICE) V(end3IBIS)

* === Simulation Time ===
.TRAN 5.0ps 50.0ns

.END
