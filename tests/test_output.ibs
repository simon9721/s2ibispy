| IBIS file test.ibs created by PYS2IBIS3
| Missouri S&T EMC Lab
[IBIS Ver] 6.0
[File Name] test.ibs
[File Rev] 0
[Date] November 17, 2025
[Source] Netlist generated by Grok
[Notes] I really wouldn't try to use this driver. It's really bad.
 You can put blank lines in any of these sections.
[Disclaimer] This file is only for demonstration purposes. It describes a really crummy driver.
[Copyright] Missouri S&T EMC Lab
[Component] MCM Driver 1
[Manufacturer] MegaFLOPS Inc.
[Package]
| variable   typ   min   max
R_pkg 0 NA NA
L_pkg 0H NA NA
C_pkg 0F NA NA
[Pin]  signal_name   model_name   R_pin   L_pin   C_pin
vss   vss   GND
vdd   vdd   POWER
| oe oe dummy
| in in dummy
out   out   driver
| End of Component
[Model] driver
Model_type I/O
Polarity Non-Inverting
Enable Active-High
Vinl  = 0.8V
Vinh  = 2V
C_comp 1.2000pF 1.0000pF 1.4000pF
[Temperature Range] 27.0000 100.0000 0.0000
[Voltage Range] 3.3000V 3.0000V 3.6000V
[Pullup Reference] 3.3000V 3.0000V 3.6000V
[Pulldown Reference] 0V 0V 0V
[POWER Clamp Reference] 3.3000V 3.0000V 3.6000V
[GND Clamp Reference] 0V 0V 0V
| End of Model
| Models and submodels in the file (1): driver (I/O)
